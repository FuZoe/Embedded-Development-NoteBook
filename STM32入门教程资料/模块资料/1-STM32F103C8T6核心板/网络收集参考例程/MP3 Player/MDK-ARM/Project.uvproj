# Keil uVision project Project.uvproj, settings and files
target HY-RedBull V3.0 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1 OneElfS=1
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\USER;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\USER\VS1003;..\USER\SD_Card;..\USER\FATFS_V0.08A\src;..\USER\MP3Header;..\USER\GLCD;..\USER\TouchPanel;..\USER\ucCos_App;..\USER\uC-CPU;..\USER\uC-LIB;..\USER\uCOS-II;..\USER\uCOS-VIEW;..\USER\MicrochipGUI_V2.10\inc;..\USER\MicrochipGUI_V2.10;..\USER\MicrochipGUI_V2.10\Font;..\USER\MicrochipGUI_V2.10\GUI_App;..\USER\Audio;..\USER\Unicode;..\USER\SPI_Flash
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../USER/: main.c stm32f10x_it.c stm32f10x_conf.h
    ../USER/ucCos_App/: uctsk_OSView.c uctsk_VS1003.c uctsk_MP3Decode.c uctsk_ReadButton.c uctsk_TouchScreen.c uctsk_MicrochipGUI.c app_cfg.h includes.h
  group GLCD
    ../USER/GLCD/: GLCD.c HzLib.c AsciiLib.c
  group Audio
    ../USER/Audio/: Audio.c
  group VS1003
    ../USER/VS1003/: vs1003.c
  group SD_Card
    ../USER/SD_Card/: sdio_sd.c
  group MP3Header
    ../USER/MP3Header/: MP3header.c
  group SPI Flash
    ../USER/SPI_Flash/: FlashDriver.c SST25VF016B.c
  group TouchPanel
    ../USER/TouchPanel/: TouchPanel.c
  group FATFS V0.08A
    ../USER/FATFS_V0.08A/src/: ff.c diskio.c ffconf.h
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../USER/: system_stm32f10x.c
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group uC-OS-II/Port
    ../USER/uCOS-II/Ports/ARM-Cortex-M3/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uC-OS-II/Source
    ../USER/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uC-OS-II/Config
    ../USER/ucCos_App/: OS_AppHooks.c os_cfg.h
  group uC-OS-II/CPU
    ../USER/uC-CPU/ARM-Cortex-M3/RealView/: cpu.h cpu_a.asm cpu_c.c
    ../USER/uC-CPU/: cpu_def.h
  group uC-OS-II/LIB/Source
    ../USER/uC-LIB/: lib_mem.c lib_str.c lib_def.h lib_mem.h lib_str.h
  group uC-OS-II/LIB/Port
    ../USER/uC-LIB/Ports/RealView/: lib_mem_a.asm
  group uC-OS-II/VIEW/Source
    ../USER/uCOS-VIEW/Source/: os_view.h os_view.c
  group uC-OS-II/VIEW/Port
    ../USER/uCOS-VIEW/Ports/ARM-Cortex-M3/Realview/: os_viewc.c os_viewc.h
  group MicrochipGUI/ASCII_Fonts
    ../USER/MicrochipGUI_V2.10/Font/: GUIFonts_ASCII.h
  group MicrochipGUI/Source
    ../USER/MicrochipGUI_V2.10/src/: Button.c Chart.c CheckBox.c DigitalMeter.c EditBox.c GOL.c GOLFontDefault.c Grid.c GroupBox.c ListBox.c Meter.c Palette.c Picture.c Primitive.c ProgressBar.c RadioButton.c RoundDial.c Slider.c StaticText.c Template.c TextEntry.c Window.c
  group MicrochipGUI/Config
    ../USER/MicrochipGUI_V2.10/: Graphics.h GraphicsConfig.h
  group MicrochipGUI/Driver
    ../USER/MicrochipGUI_V2.10/src/: TouchScreen.c drvTFT001.c
  group MicrochipGUI/Menu
    ../USER/MicrochipGUI_V2.10/GUI_App/: Menu.h menu.c GOLMsgCallback.c GOLDrawCallback.c
  group MicrochipGUI/Mask
    ../USER/MicrochipGUI_V2.10/: externalref.c Pictures.c
  group Doc
    ../: readme.txt
